# Keil uVision project RM_Sentry.uvprojx, settings and files
target RM_Sentry (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: RM_Sentry +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx,__TARGET_FPU_VFP=1,ARM_MATH_CM4,__CC_ARM
  c include: ../Inc;                              ../Drivers/STM32F4xx_HAL_Driver/Inc;                              ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                              ../Middlewares/Third_Party/FreeRTOS/Source/include;                              ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                              ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                              ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                              ../Drivers/CMSIS/Include;                              ..\BSP\BSP.h;                              ..\User\User.h;                              ..\Device\Device.h;                              ..\App\App.h;                              ..\Arithmetic\Arithmetic.h;                              ..\Drivers\CMSIS\DSP\Include
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/User
    ../Src/: main.c gpio.c freertos.c can.c dma.c rng.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group BSP
    ../BSP/BSP.c/: user_UART.c
  group Device
    ../BSP/BSP.c/: user_CAN.c
    ../Device/Device.c/: GM6020.c M3508.c Debug_DataScope.C DR16.c Vision.c PEswitch.c M2006.c Encoder.c RM_JudgeSystem.c ANO.c Wolf_GyIMU.c DJI_C_IMU.c Broad_Communicate.c Limit_switch.c Sensor.c CAN2_SEND.c
  group App
    ../App/App.c/: Chassis_Control.c Cloud_Control.c Vision_Control.c Shoot_Control.c Robots_Control.c PowerLimit_Control.c Robots_Detection.c Random_Gain.c Driver_Control.c Heat_Control.c Attack_Control.c BREAK.c
  group Arithmetic
    ../Arithmetic/Arithmetic.c/: User_math.c Filter_fuction.c PID_Position.c PID_Increment.c CRC.c kalman.c
  group User
    ../User/User.h/: User_common.h Handle.h User_typedef.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_rng.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ../Src/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
software components: CMSIS:CORE 4.3.0
